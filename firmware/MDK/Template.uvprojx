# Keil uVision project Template.uvprojx, settings and files
target TEMPLATE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,SYSTEM_FREERTOS_ENABLED
  c include: ..\DriverLayer;..\HelpLayer;..\PeripheralOnchip;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\ThirdPart\FreeRTOS\include;..\ThirdPart\FreeRTOS\portable\RVDS\ARM_CM3;..\ThirdPart\eMPL;..\ThirdPart\VL53L0\core\inc;..\ThirdPart\VL53L0\platform\inc;..\ThirdPart\FATFS;..\ThirdPart\FATFS\exfuns;..\LogicLayer\logic;..\LogicLayer\config;..\LogicLayer\system;..\Libraries\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group logic
    ../LogicLayer/logic/: main.c my_logic.c pin_conf.h
  group System
    ../LogicLayer/system/: delay.c int_manage.c stm32f1xx_hal_msp.c stm32f1xx_it.c sys.c system_stm32f1xx.c startup_stm32f103xb.s sys_cfg.h
  group Config
    ../LogicLayer/config/: app_conf.h driver_conf.h FreeRTOSConfig.h help_conf.h onchip_conf.h stm32f1xx_hal_conf.h
  group HelpLayer
    ../HelpLayer/: algorithm.c data_cut.c log.c my_pid.c reg.c my_list.h hash.c
  group PeripheralOnchip
    ../PeripheralOnchip/: my_adc.c my_adc.h my_uart_dma.c my_uart_dma.h
  group ThirdPart/FreeRTOS
    ../ThirdPart/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../ThirdPart/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../ThirdPart/FreeRTOS/portable/MemMang/: heap_4.c
  group Libraries
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Driver
    ../DriverLayer/: switch.c switch.h esp8266_wifi.c esp8266_wifi.h
  group Environment drivers
    ../DriverLayer/: dht11.c ds3231.c
    ../PeripheralOnchip/: my_iic.c
